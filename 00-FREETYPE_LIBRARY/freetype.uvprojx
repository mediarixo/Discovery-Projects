# Keil uVision project freetype.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: freetype (library)
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group base
    ./src/base/: ftsystem.c ftdebug.c ftinit.c ftbase.c ftbbox.c ftbitmap.c ftglyph.c ftstroke.c ftsynth.c
  group truetype
    ./src/truetype/: truetype.c
  group sfnt
    ./src/sfnt/: sfnt.c
  group pshinter
    ./src/pshinter/: pshinter.c
  group smooth
    ./src/smooth/: smooth.c
  group gzip
    ./src/gzip/: ftgzip.c
  group psnames
    ./src/psnames/: psnames.c
